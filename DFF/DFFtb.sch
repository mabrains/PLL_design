v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 420 -450 450 -450 {
lab=Qbar}
N 420 -560 450 -560 {
lab=Q}
N 180 -560 210 -560 {
lab=D}
N 180 -450 190 -450 {
lab=clk}
N 190 -450 210 -450 {
lab=clk}
N 310 -410 310 -380 {
lab=rstn}
C {untitled.sym} 70 -320 0 0 {name=X1}
C {devices/ipin.sym} 190 -560 0 0 {name=p1 lab=D
}
C {devices/ipin.sym} 190 -560 0 0 {name=p2 lab=D}
C {devices/ipin.sym} 190 -450 0 0 {name=p3 lab=clk}
C {devices/ipin.sym} 310 -390 3 0 {name=p4 lab=rstn}
C {devices/opin.sym} 440 -560 0 0 {name=p5 lab=Q}
C {devices/opin.sym} 440 -450 0 0 {name=p6 lab=Qbar}
