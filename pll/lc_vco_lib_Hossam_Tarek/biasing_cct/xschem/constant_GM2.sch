v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
