** sch_path: pll/xctl_lib/crystal_osc/schematic/untitled.sch
**.subckt untitled
R1 net3 net2 1k m=1
L1 net2 net1 1n m=1
C1 net1 net4 1p m=1
**.ends
.end
