v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {Delay_cell_M.sym} 40 0 0 0 {}
