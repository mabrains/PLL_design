v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {Delay_cell_2.sym} 110 0 0 0 {name=X1}
